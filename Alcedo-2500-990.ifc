Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: 2018_01
Time: 2025-10-06T13:13:27+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.1.318 - Exporter 23.0.1.318 - Default UI

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 519 m
Sonstige - Auftraggeber: Bauherr; Kategorie: Projektinformationen; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektnummer: 2018_01; Projektstatus: Projekt Status; Verfasser eMail: E-Mail; Verfasser Firma 1: AUTODESK GmbH; Verfasser PLZ Ort: Ort; Verfasser Strasse: Adresse; Verfasser Telefon: Telefon; Verfasser URL: www.Autodesk.de/BIM
Text - Bauherr: AUTODESK; Baustellenort: BAUORT; Baustellenstraße: BAUSTRASSE 1; Einlagezahl: 123-45; Gerichtsbezirk: GERICHTSBEZIRK; Grundstücksnummer: GR; Katastralgemeinde: KG; Kundenadresse: KUNDENSTRASSE 1; Kundenort: KUNDENORT; Kundentelefon: 0000-00000-1; Kundenzusatz: KUNDENZUSATZ

# IfcBuildingElementProxy: Familie1:Norm, Familie1:Norm:2420207
In: Default
Type - Material: Metall - Alu(glänzend) (7), Vorgabe_1 (3), Zink (21), <Unnamed> (2)
Type - Abhängigkeiten - Vorgabe-Ansicht: 0 m
Type - Bemaßungen - Verbindung_1_Durchmesser: 0.012 m; Verbindung_2_Durchmesser: 0.012 m
Type - ID-Daten - Typname: Norm
Type - Modelleigenschaften - Autor: M36842; Bauteilnummer: Alcedo-2500-1000; Erstellungsdatum: 06.10.2025; Firma: Krantz GmbH; Konstrukteur: M36842; Konstruktionsstatus: 1
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Familie1
Pset_BuildingElementProxyCommon - Reference: Norm; sets with these values: 2
Abhängigkeiten - Basisbauteil: Keine; Höhe von Ebene: 0 m; Versatz von Host: 0 m
Bemaßungen - Fläche: 5.31245 m2; Volumen: 0.00953619 m3
Phasen - Phase erstellt: Phase 2
Sonstige - Familie: Familie1; Familie und Typ: Familie1: Norm; Typ: Norm; Typ-ID: 2420192

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK
